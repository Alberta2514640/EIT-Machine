File: PCB_Design/vccs.kicad_sch (KiCad schematic)
At the start: 10 parts, among them U20 OPA4228UA

Commit message: Update KiCAD files to KiCAD 8.0
Parts:
- renumbered U20 to U24
